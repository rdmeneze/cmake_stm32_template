# Keil uVision project Project.uvprojx, settings and files
target STM32L496G-Discovery (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32L496AGIx STMicroelectronics
  pack: STMicroelectronics.STM32L4xx_DFP.1.0.1
  cpu: IROM(0x08000000-0x807FFFF) IROM_TARA(0x08080000-0x80BFFFF) IROM_TGFX(0x080C0000-0x80FE7FF) IROM_While(0x080FE800-0x80FFBFF) IRAM(0x20000000-0x2003FFFF) IRAM2(0x10000000-0x1000FFFF) CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4")
  output: STM32CubeDemo_STM32L496G-Discovery-MB1261-B01 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32L496xx,USE_FULL_ASSERT,USE_FULL_LL_DRIVER,DIM_FEATURE_ENABLED,INIT_BLACK_LCD
  c misc: --wchar32
  c include: ../STemWin_Addons;../Core/inc;../Config;../Modules/audio_player;../Modules/audio_recorder;../Modules/iddmeasure;../Modules/usb_storage;../Modules/main_app;../Modules/common;../Modules/videoplayer;../../../../Utilities/CPU;../../../../Drivers/CMSIS/Include;../../../../Drivers/CMSIS/Device/ST/STM32L4xx/Include;../../../../Drivers/STM32L4xx_HAL_Driver/Inc;../../../../Drivers/BSP/STM32L496G-Discovery;../../../../Drivers/BSP/Components;../../../../Drivers/BSP/Components/ft6x06;../../../../Drivers/BSP/Components/ft3x67;../../../../Drivers/BSP/Components/st7789h2;../../../../Drivers/BSP/Components/mx25r6435f;../../../../Middlewares/ST/STM32_USB_Device_Library/Class/MSC/Inc;../../../../Middlewares/ST/STM32_USB_Device_Library/Core/Inc;../../../../Middlewares/ST/STemWin/inc;../../../../Middlewares/Third_Party/FatFs/src;../../../../Middlewares/Third_Party/FatFs/src/drivers;../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../../../../Middlewares/Third_Party/FreeRTOS/Source/include;../../../../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS
  asm include: ../Config
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x40000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: STM32L496G-Discovery\Exe\STM32CubeDemo_STM32L496G-Discovery-MB1261-B01.sct
  link misc: --keep=*.o(.TARAFlashSection) --keep=*.o(.TGFXFlashSection) --keep=*.o(.TARAResSection) --keep=*.o(.TGFXResSection)
  group Application/MDK-ARM
    ./: startup_stm32l496xx.s
  group Application/User/Core
    ../Core/Src/: k_bsp.c k_calibration.c k_menu.c k_mfx.c k_module.c k_rtc.c k_sd_diskio.c k_startup.c k_storage.c main.c stm32l4xx_hal_timebase_tim.c stm32l4xx_it.c
    ../../../../Middlewares/Third_Party/FatFs/src/: diskio.c ff.c ff_gen_drv.c
    ../../../../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
  group Application/User/Modules/Analog_Clock
    ../Modules/analog_clock/: analog_clock_win.c
  group Application/User/Modules/Audio_Player
    ../Modules/audio_player/: audio_player_app.c audio_player_win.c
  group Application/User/Modules/Audio_Recorder
    ../Modules/audio_recorder/: audio_recorder_app.c audio_recorder_win.c
  group Application/User/Modules/back_STemWin
    ../Modules/back_STemWin/: BackSTemWin_win.c
  group Application/User/Modules/Common
    ../Modules/common/: audio_if.c
  group Application/User/Modules/EmbeddedWizard_demo
    ../Modules/third_party_tara/: EmbeddedWizard_bin.c EmbeddedWizard_win.c EWIZ_resources.c
  group Application/User/Modules/IDD_Measure
    ../Modules/iddmeasure/: iddmeasure.c iddmeasure_win.c
  group Application/User/Modules/Information
    ../Modules/information/: information_win.c
  group Application/User/Modules/STemWin_demo
    ../Modules/STemWin_demo/: STemWin_win.c
  group Application/User/Modules/TouchGFX_demo
    ../Modules/third_party_touchGFX/: TGFX_Lite_resources.c TouchGFX_bin.c TouchGFX_win.c
  group Application/User/Modules/TouchGFX_FULLdemo
    ../Modules/third_party_touchGFX_FULL/: TouchGFX_FULL_win.c
  group Application/User/Modules/USB_Storage
    ../Modules/usb_storage/: usb_storage_win.c usbd_app.c usbd_desc.c usbd_storage.c
  group Application/User/Modules/Video_Player
    ../Modules/videoplayer/: GUI_AVI.c video_player_win.c
  group Doc
    ../: readme.txt
  group Drivers/BSP/Component
    ../../../../Drivers/BSP/Components/cs42l51/: cs42l51.c
    ../../../../Drivers/BSP/Components/ft6x06/: ft6x06.c
    ../../../../Drivers/BSP/Components/ft3x67/: ft3x67.c
    ../../../../Drivers/BSP/Components/mfxstm32l152/: mfxstm32l152.c
    ../../../../Drivers/BSP/Components/st7789h2/: st7789h2.c
  group Drivers/BSP/STM32L496G-Discovery
    ../../../../Drivers/BSP/STM32L496G-Discovery/: stm32l496g_discovery.c stm32l496g_discovery_audio.c stm32l496g_discovery_idd.c stm32l496g_discovery_io.c stm32l496g_discovery_lcd.c stm32l496g_discovery_qspi.c stm32l496g_discovery_sd.c stm32l496g_discovery_ts.c
  group Drivers/CMSIS
    ../../../../Drivers/CMSIS/Device/ST/STM32L4xx/Source/Templates/: system_stm32l4xx.c
  group Drivers/STM32L4xx_HAL_Drivers
    ../../../../Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal.c stm32l4xx_hal_adc.c stm32l4xx_hal_adc_ex.c stm32l4xx_hal_cortex.c stm32l4xx_hal_crc.c stm32l4xx_hal_crc_ex.c stm32l4xx_hal_dfsdm.c stm32l4xx_hal_dma.c stm32l4xx_hal_flash.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal_flash_ramfunc.c stm32l4xx_hal_gpio.c stm32l4xx_hal_i2c.c stm32l4xx_hal_i2c_ex.c stm32l4xx_hal_iwdg.c stm32l4xx_hal_lcd.c stm32l4xx_hal_pcd.c stm32l4xx_hal_pcd_ex.c stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_qspi.c stm32l4xx_hal_rcc.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_rng.c stm32l4xx_hal_rtc.c stm32l4xx_hal_rtc_ex.c stm32l4xx_hal_sai.c stm32l4xx_hal_sd.c stm32l4xx_hal_spi.c stm32l4xx_hal_spi_ex.c stm32l4xx_hal_sram.c stm32l4xx_hal_tim.c stm32l4xx_hal_tim_ex.c stm32l4xx_ll_dma2d.c stm32l4xx_ll_fmc.c stm32l4xx_ll_sdmmc.c stm32l4xx_ll_usb.c stm32l4xx_hal_uart.c stm32l4xx_hal_uart_ex.c
  group Middlewares/FatFs/Core
    ../Core/Src/: k_bsp.c k_calibration.c k_menu.c k_mfx.c k_module.c k_rtc.c k_sd_diskio.c k_startup.c k_storage.c main.c stm32l4xx_hal_timebase_tim.c stm32l4xx_it.c
    ../../../../Middlewares/Third_Party/FatFs/src/: diskio.c ff.c ff_gen_drv.c
    ../../../../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
  group Middlewares/FatFs/Options
    ../../../../Middlewares/Third_Party/FatFs/src/option/: syscall.c unicode.c
  group Middlewares/FreeRTOS
    ../../../../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group Middlewares/FreeRTOS/Portable
    ../../../../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group Middlewares/STemWin/Config
    ../Config/: GUIConf.c LCDConf.c
  group Middlewares/STemWin/Library
    ../../../../Middlewares/ST/STemWin/Lib/: STemWin_CM4_OS_wc32_ot.a
  group Middlewares/STemWin/OS
    ../../../../Middlewares/ST/STemWin/OS/: GUI_X_OS.c
  group Middlewares/USBD_Library/Class/MSC
    ../../../../Middlewares/ST/STM32_USB_Device_Library/Class/MSC/Src/: usbd_msc.c usbd_msc_bot.c usbd_msc_data.c usbd_msc_scsi.c
  group Middlewares/USBD_Library/Config
    ../Config/: usbd_conf.c
  group Middlewares/USBD_Library/Core
    ../Core/Src/: k_bsp.c k_calibration.c k_menu.c k_mfx.c k_module.c k_rtc.c k_sd_diskio.c k_startup.c k_storage.c main.c stm32l4xx_hal_timebase_tim.c stm32l4xx_it.c
    ../../../../Middlewares/Third_Party/FatFs/src/: diskio.c ff.c ff_gen_drv.c
    ../../../../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
software components: CMSIS:CORE 4.3.0
